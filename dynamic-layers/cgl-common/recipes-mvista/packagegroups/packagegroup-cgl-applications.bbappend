RDEPENDS:packagegroup-cgl-applications:append = " \
	monit \
"
