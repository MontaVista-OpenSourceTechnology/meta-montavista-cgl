RDEPENDS:packagegroup-oe-console-utilities-cgl:append = " \
	cryptsetup \
"
