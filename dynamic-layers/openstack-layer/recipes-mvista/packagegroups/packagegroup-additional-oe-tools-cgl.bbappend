RDEPENDS:packagegroup-oe-webserver-cgl:append = " \
	mod-wsgi \
"

RDEPENDS:packagegroup-oe-filesystem-utilities-cgl:append = " \
	tgt \
"
