RDEPENDS:packagegroup-cge-utility-hardware:append = " \
	drbd-utils \
	openhpi \
	openipmi \
	nbd-client \
	nbd-server \
	nbd-trdump \
"

RDEPENDS:packagegroup-cge-utility-system-management:append = " \
	lksctp-tools \
"

RDEPENDS:packagegroup-cge-utility-network-management:append = " \
	stunnel \
"

RDEPENDS:packagegroup-cge-libs:append = " \
	opensaf \
"
