RDEPENDS:packagegroup-oe-console-utilities-cgl:append = " \
	lxc \
"
