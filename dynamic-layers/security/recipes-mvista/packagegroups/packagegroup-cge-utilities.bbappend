RDEPENDS:packagegroup-cge-utility-hardware:append = " \
	paxctl \
"
