RDEPENDS:packagegroup-cge-utility-system-management:append = " \
	adduser \
"

RDEPENDS:packagegroup-cge-logs-management:append = " \
	logcheck \
"
