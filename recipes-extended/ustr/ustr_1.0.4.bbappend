FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://ustr-gcc-5+.diff"
