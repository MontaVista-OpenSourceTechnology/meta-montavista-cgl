PR .= ".1"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://access-skc_v6_daddr-iff-IPV6-defined.patch"

