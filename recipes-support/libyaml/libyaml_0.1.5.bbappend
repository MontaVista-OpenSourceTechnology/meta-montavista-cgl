PR .= ".1"
FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://libyaml-CVE-2014-9130.patch"
