SRC_URI_remove = "file://misc_create_inode.c-label_rootfs.patch"
